<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>2.492e9</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
